File: 68kshunt/68kshunt.sch (EAGLE design)
At the start: 2 parts

Commit message: Updates to the board files.
Parts:
- renumbered IC1 to BOTTOM, IC2 to TOP
